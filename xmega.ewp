# IAR project xmega.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x50
  General.SCRStackSize: 20
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6l-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a1u ATxmega128A1U
  ICCAVR.CCDefines: __xmega128A1U__; F_CPU=2000000
  ICCAVR.newCCIncludePaths: include
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  ICCAVR.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1u.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.cpp
  group include
    include/: board.h
  group include/boost
    include/boost/: static_assert.hpp tmp.hpp
  group include/device
    include/device/: device.hpp gpio.hpp register.hpp
  group include/device/peripherals
    include/device/peripherals/: AC.hpp ADC.hpp AES.hpp AWEX.hpp CLK.hpp CPU.hpp CRC.hpp DAC.hpp DFLL.hpp DMA.hpp EBI.hpp EVSYS.hpp FUSE.hpp GPIO.hpp HIRES.hpp IRCOM.hpp LOCKBIT.hpp MCU.hpp NVM.hpp OSC.hpp PMIC.hpp PORT.hpp PORTCFG.hpp PR.hpp RST.hpp RTC.hpp SIGROW.hpp SLEEP.hpp SPI.hpp TC.hpp TC2.hpp TWI.hpp USART.hpp USB.hpp VPORT.hpp WDT.hpp XOCD.hpp
  group include/drivers
    include/drivers/: adc.h uart.h
